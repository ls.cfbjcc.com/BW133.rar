!  2-Port S-parameters saved by WinCal
! VAR MeasName=S-Parameters (CALIBRATED_DATA) read from VNA (N5244A)
! VAR MeasDate=2013-8-7 14:07:24
! VAR NAME=136504
! VAR FILENAME=136504.S2P
! VAR DATE=2013-8-7 14:07:24
! VAR PHYS_PORTS=1,2
# Hz S MA R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 100 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -16.24 dB at 149.9 MHz (marker M1); lowest = -25.7 dB at 15.31 GHz (marker M2)
!   lowest |S11| = -37.5 dB at 39.85 GHz (marker M3), VSWR 1.03, Z = 50.7 + j1.14 ohm
!   |S11| at or under -10 dB: 19.77 GHz to 20.34 GHz (575.2 MHz wide, 2.87 % of centre); 20.35 GHz to 22.08 GHz (1.726 GHz wide, 8.13 % of centre); 22.82 GHz to end of sweep (the widest 3 of 22)
!   |S22| runs from -4.5 to -1.5 dB; largest |S21 - S12| = 0.0043
!   the Smith chart shows 33.57 GHz to 40 GHz only
!   S11 on the Smith chart (normalised r, x): 33.57 GHz: 0.69, +0.01; 36.51 GHz: 0.73, +0.20; 40 GHz: 0.98, +0.14
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 MHz  -1.5  -16.2  -16.3  -1.5
! 149.9 MHz  -1.5  -16.2  -16.3  -1.5
! 6.783 GHz  -4.5  -20.4  -20.5  -2.3
! 13.42 GHz  -8.2  -23.5  -23.6  -2.9
! 15.31 GHz  -8.1  -25.7  -25.8  -2.9
! 20.05 GHz  -12.6  -24.6  -24.4  -3.1
! 21.2 GHz  -17.7  -25.0  -24.8  -3.2
! 22.79 GHz  -9.2  -23.1  -23.0  -3.3
! 24.24 GHz  -21.3  -24.9  -25.1  -3.4
! 25.19 GHz  -10.9  -23.2  -23.2  -3.4
! 26.73 GHz  -16.6  -24.5  -24.7  -3.5
! 28.08 GHz  -21.5  -24.4  -24.6  -3.6
! 29.63 GHz  -11.7  -23.6  -23.7  -3.6
! 31.82 GHz  -22.6  -24.5  -24.5  -3.8
! 33.37 GHz  -11.8  -24.6  -24.7  -3.9
! 33.57 GHz  -14.7  -25.1  -25.2  -4.0
! 34.86 GHz  -21.8  -24.4  -24.5  -4.0
! 36.51 GHz  -14.3  -25.3  -25.5  -4.2
! 39.05 GHz  -27.7  -23.0  -23.1  -4.4
! 39.5 GHz  -17.1  -23.3  -23.3  -4.4
! 39.85 GHz  -37.5  -22.5  -22.5  -4.4
! 40 GHz  -22.8  -23.1  -23.1  -4.4
